# Keil uVision project nfc_url_record_pca10040.uvprojx, settings and files
target nrf52832_xxaa (ARM-ADS)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.2.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52832_xxaa +hex
  c flags: Optim=4 OneElfS=1
  c define: BSP_DEFINES_ONLY BOARD_PCA10040 CONFIG_GPIO_AS_PINRESET NRF52
  c misc: --c99
  c include: ..\..;..\..\..\..\bsp;..\..\..\..\..\components\libraries\util;..\..\..\..\..\components\libraries\experimental_nfc\nfc_lib;..\..\..\..\..\components\libraries\experimental_nfc\uri;..\..\..\..\..\components\device;..\..\..\..\..\components\toolchain;..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\components\libraries\experimental_nfc\hal_nfc;..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd
  asm define: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ../../: main.c
  group Documentation
    ../../: Abstract.txt license.txt
  group nRF_Libraries
    ../../../../../components/libraries/util/: app_error.c
    ../../../../../components/libraries/experimental_nfc/hal_nfc/: hal_nfc.c
    ../../../../../components/libraries/experimental_nfc/nfc_lib/: nfc_lib.lib
    ../../../../../components/libraries/experimental_nfc/uri/: nfc_uri_msg.c
software components: CMSIS:CORE 3.40.0, Device:Startup 8.0.3
