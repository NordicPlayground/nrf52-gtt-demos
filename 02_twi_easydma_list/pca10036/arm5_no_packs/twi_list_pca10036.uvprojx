# Keil uVision project twi_list_pca10036.uvprojx, settings and files
target nrf52_mpw3 (ARM-ADS)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.2.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: twi_list_pca10040 +hex
  c flags: Optim=1 OneElfS=1
  c define: NRF52 DEBUG_NRF BOARD_PCA10036 CONFIG_GPIO_AS_PINRESET SWI_DISABLE0
  c misc: --c99
  c include: ..\..\config;..\..;..\..\..\..\bsp;..\..\..\..\..\components\libraries\uart;..\..\..\..\..\components\drivers_nrf\twis_slave;..\..\..\..\..\components\drivers_nrf\config;..\..\..\..\..\components\drivers_nrf\twi_master;..\..\..\..\..\components\libraries\button;..\..\..\..\..\components\drivers_nrf\gpiote;..\..\..\..\..\components\libraries\util;..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\components\device;..\..\..\..\..\components\toolchain;..\..\..\..\..\components\libraries\fifo;..\..\..\..\..\components\drivers_nrf\uart;..\..\..\..\..\components\drivers_nrf\delay;..\..\..\..\..\components\libraries\timer;..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd;..\..\..\..\..\components\drivers_nrf\ppi;..\..\..\..\..\components\drivers_nrf\rtc
  asm define: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ../../: main.c mma7660.c
  group Documentation
    ../../: Abstract.txt license.txt
  group nRF_Drivers
    ../../../../../components/libraries/uart/: app_uart_fifo.c
    ../../../../../components/drivers_nrf/delay/: nrf_delay.c
    ../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../../components/drivers_nrf/uart/: nrf_drv_uart.c
    ../../: nrf_drv_twi_mod.c
    ../../../../../components/drivers_nrf/ppi/: nrf_drv_ppi.c
    ../../../../../components/drivers_nrf/rtc/: nrf_drv_rtc.c
  group nRF_Libraries
    ../../../../../components/libraries/util/: app_error.c app_util_platform.c nrf_assert.c
    ../../../../../components/libraries/fifo/: app_fifo.c
    ../../../../../components/libraries/uart/: retarget.c
software components: CMSIS:CORE 3.40.0, Device:Startup 8.0.3
